<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\F405_Storage.ewp</path>
  </project>
  <batchBuild />
</workspace>
